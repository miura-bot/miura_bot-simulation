Commit message: Merge branch 'main' of https://github.com/miura-bot/miura_bot-simulation

File: wheel_with_motor.urdf (robot description, URDF)
Before this commit: robot wheel_with_motor, 2 links, 1 joints
Joints:
- joint joint1: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0 rpy=0.0 0 1.5708
